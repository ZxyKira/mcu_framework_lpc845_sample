# Keil uVision project mcu_framework_lpc845_sample.uvprojx, settings and files
target mcu_framework_lpc845_sample (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC845M301JBD64 NXP
  pack: NXP.LPC845_DFP.12.2.0
  cpu: IRAM(0x10003fe0,0x20) IRAM2(0x10000000,0x3fe0) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mcu_framework_lpc845_sample
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: NDEBUG, CPU_LPC845M301JBD64
  c include: ..\source\import;..\source\startup;..\source\main;..\source\tool;..\source\task;..\source\periph;..\reference\mcu_driver_lpc845;..\reference\mcu_framework;..\reference\mcu_framework_lpc845;..\reference\tool_fifo;..\reference\tool_task_scheduler;..\reference\tool_timer_scheduler;..\reference\tool_ring_buffer
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10003fe0 size 0x20
  memory RVCT10: RAM 0x10000000 size 0x3fe0
  scatter file: .\LPC845_flash.scf
  group import
    ../source/import/: version.h chip_interrupt_service_routine.c
  group startup
    ../source/startup/: system_LPC845.c system_LPC845.h startup_LPC845.s
  group main
    ../source/main/: loop.c main.c start.c pinmux.c nvic_priority.c main.h pinmux.h
  group tool
    ../source/tool/: timer_scheduler.c task_schuduler.c tool.h
  group periph
    ../source/periph/: speaker.c console.c dashboard.c periph.h
  group task
    ../source/task/: task_led.c task_button.c task.h
  group reference_mcu_framework_lpc845
    ../reference/mcu_framework_lpc845/source/: chip_construct.c chip_intsw.c chip_io.c chip_io_pin.c chip_iocon.c chip_ioint.c chip_power.c chip_spim.c chip_swm.c chip_timer_mrt.c chip_usart.c chip_i2cm.c chip_interrupt_ctrl.c chip_interrupt_ctrl.h
  group reference_tool_ring_buffer
    ../reference/tool_ring_buffer/source/: tool_ring_buffer.c
  group reference_tool_fifo
    ../reference/tool_fifo/source/: tool_fifo.c
  group reference_tool_task_scheduler
    ../reference/tool_task_scheduler/source/: tool_task_scheduler.c
  group reference_tool_timer_scheduler
    ../reference/tool_timer_scheduler/source/: tool_timer_scheduler.c
  group reference_mcu_driver_lpc845
    ../reference/mcu_driver_lpc845/source/: fsl_acomp.c fsl_adc.c fsl_capt.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dac.c fsl_dma.c fsl_gpio.c fsl_i2c.c fsl_iap.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_sctimer.c fsl_spi.c fsl_swm.c fsl_syscon.c fsl_usart.c fsl_wkt.c fsl_wwdt.c
